Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-08-29T13:25:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.0.1185.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 29 13:25:48 2017 * Host: WITAS2 * Database: C:\Users\WITAS_~1\AppData\Local\Temp\{BFAD4128-E9D5-464D-BE04-069DBF88E1EA}\ifc * Database version: 5507 * Database creation date: Tue Aug 29 13:25:48 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 29 13:25:48 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 29 13:25:48 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: E5M441R1-LEDN090S - pendel, Dummy:E5M441R1-LEDN090S - pendel:212989
In: Level 1
Type - Material: BE_G Glas lamp, BE Armatuur
Type - Constraints - Default Elevation: 1000 mm; WT_H Behuizing: Standaard; WT_H Bevestiging: BE_E Armatuur - pendel: Pendel - 2 pendelkabels; WT_H Breedte: 78 mm; WT_H Halve breedte negatief: -39 mm; WT_H Halve lengte negatief: -576 mm; WT_H Hoogte: 85 mm; WT_H Inbouwdiepte: 0 mm; WT_H Lengte: 1152 mm; WT_H Lichtbron_breedte: 70.2 mm; WT_H Lichtbron_lengte: 1036.8 mm; WT_H Opbouw: no; WT_H Optiek: E5_41R1; WT_H Optiek 1_X coördinaat: 0 mm; WT_H Optiek 1_Y coördinaat: 0 mm; WT_H Pendel_breedte: 60 mm; WT_H Pendel_lengte: 1072 mm; WT_H Pendel horizontale armatuurmontage: yes; WT_H Referentie: Pendel - horizontale armatuurmontage; WT_H Symbool wand hoogte: 78 mm; WT_H Symbool wand lengte: 1152 mm; WT_H Uitsteek: 0 mm
Type - Dimensions - BE_G Breedte: 78 mm; BE_G Hoogte: 85 mm; BE_G Lengte: 1152 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 60.9 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 60.9 W
Type - Graphics - WT_V Symbool plafond: led-rechthoekige; WT_V Symbool wand: geen
Type - Identity Data - BE_I Bestelcode: E5M441R1/LEDN090S; Manufacturer: ETAP; Model: E5M; Type Name: E5M441R1-LEDN090S - pendel; URL: http://www.etaplighting.com/level2.aspx?seq=86&seqpicture=2227&name=Verlichting&LangType=2067; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - BE_G Materiaal/Kleur: BE Armatuur; WT_V Materiaa_lichtbron: BE_G Glas lamp
Type - Model Properties - WT_I Armatuurrendement: 0.9; WT_I Kleur: -; WT_I Maatschets catalogus: -; WT_I Montage: pendel; WT_I Optiek: lens; WT_I Type: In lijn; WT_I UGR: 0; WT_I Voorschakelapparaat: S; WT_I Vorm: langwerpig
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP E5M - lichtbron - LED: E5M441R1_LEDN090S; WT_I Lamptype: LED; WT_I Vermogen lamp: 60.9 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: E5M441R1-LEDN090S - pendel
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Offset lichtbron: 290 mm; WT_H Optiek_type 1: E5_41R1
Construction - WT_V Pendelhoogte: 200 mm
Dimensions - Area: 0.778189 m2; Volume: 0.0305515 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-61 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 10
Other - Family: Dummy: E5M441R1-LEDN090S - pendel; Family and Type: Dummy: E5M441R1-LEDN090S - pendel; Schedule Level: Level: Level 1; Type: Dummy: E5M441R1-LEDN090S - pendel; Type Id: Dummy: E5M441R1-LEDN090S - pendel
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Pendel - 2 pendelkabels, BE_E Armatuur - pendel:Pendel - 2 pendelkabels:212990
In: Level 1
Type - Constraints - Default Elevation: 1219.2 mm; WT_H Geen: no; WT_H Pendel: yes; WT_H Pendel_1 pendelkabel: no; WT_H Pendel_2 pendelkabels: yes
Type - Construction - WT_V Pendel_voet: no
Type - Identity Data - Cost: 0; Type Name: Pendel - 2 pendelkabels; WT_I BaseKeynote: 63.9
Type - Other - Category: Lighting Fixtures; Family Name: BE_E Armatuur - pendel
Type - Text - WT_I Revit handleiding: http://rme-be-nl-localiser.blogspot.com/2010/06/familie-armaturen.html
Pset_DistributionFlowElementCommon - Reference: Pendel - 2 pendelkabels
Constraints - Moves With Nearby Elements: no; WT_H Breedte: 78 mm; WT_H Lengte: 1152 mm
Construction - WT_V Pendelhoogte: 200 mm
Dimensions - Volume: 0.0000028273 m3
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 11
Other - Family: BE_E Armatuur - pendel: Pendel - 2 pendelkabels; Family and Type: BE_E Armatuur - pendel: Pendel - 2 pendelkabels; Type: BE_E Armatuur - pendel: Pendel - 2 pendelkabels; Type Id: BE_E Armatuur - pendel: Pendel - 2 pendelkabels
Phasing - Phase Created: New Construction
